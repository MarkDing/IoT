# IAR project Z3Aliyun3011.ewp, settings and files
configuration Normal (ARM, debug)
  General.OGChipSelectEditMenu: EFR32MG12P433F1024GL125 SiliconLaboratories EFR32MG12P433F1024GL125
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: APP_GECKO_INFO_PAGE_BTL; CORTEXM3; CORTEXM3_EFR32; CORTEXM3_EFR32_MICRO; CORTEXM3_EFM32_MICRO; EFR32_SERIES1_CONFIG2_MICRO; EFR32MG12P; EFR32MG12P433F1024GL125; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/Z3Aliyun3011/Z3Aliyun3011_endpoint_config.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; GENERATED_TOKEN_HEADER="app/builder/Z3Aliyun3011/Z3Aliyun3011_tokens.h"; PLATFORM_HEADER="platform/base/hal/micro/cortexm3/compiler/iar.h"; ZA_GENERATED_HEADER="app/builder/Z3Aliyun3011/Z3Aliyun3011.h"; __SOURCEFILE__="$FILE_FNAME$"; HAL_CONFIG=1; EMBER_AF_USE_HWCONF; EMBER_ROUTE_TABLE_SIZE=32; EMBER_AF_API_EMBER_TYPES="stack/include/ember-types.h"; EMBER_AF_API_DEBUG_PRINT="app/framework/util/print.h"; EMBER_AF_API_AF_HEADER="app/framework/include/af.h"; EMBER_AF_API_AF_SECURITY_HEADER="app/framework/security/af-security.h"; EMBER_STACK_ZIGBEE; MBEDTLS_CONFIG_FILE="stack/config/mbedtls/config-trng.h"; USE_NVM3; NVM3_DEFAULT_NVM_SIZE=NVM3_FLASH_PAGES*FLASH_PAGE_SIZE; EMLIB_USER_CONFIG; MICRIUMOS; APPLICATION_TOKEN_HEADER="app/builder/Z3Aliyun3011/afv2-token.h"; APPLICATION_MFG_TOKEN_HEADER="app/builder/Z3Aliyun3011/afv2-mfg-token.h"; NVM3_FLASH_PAGES=18; NVM3_DEFAULT_CACHE_SIZE=512; NVM3_MAX_OBJECT_SIZE=254; NVM3_DEFAULT_REPACK_HEADROOM=0; PHY_RAIL=1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros; --separate_cluster_for_initialized_variables
  ICCARM.CCIncludePath2: $FILE_DIR$; $PROJ_DIR$; ..\..\..; ..\..\..\protocol\zigbee\app\framework; ..\..\..\protocol\zigbee\app\framework\..\..; ..\..\..\protocol\zigbee\app\framework\..\..\stack; ..\..\..\protocol\zigbee\app\framework\..\util; ..\..\..\protocol\zigbee\app\framework\include; ..\..\..\platform\base\hal; ..\..\..\platform\base\hal\plugin; ..\..\..\platform\base\hal\..; ..\..\..\platform\base\hal\micro\cortexm3\efm32; ..\..\..\platform\base\hal\micro\cortexm3\efm32\config; ..\..\..\platform\base\hal\micro\cortexm3\efm32\efr32; ..\..\..\platform\base\hal\..\..\CMSIS\Include; ..\..\..\platform\base\hal\..\..\Device\SiliconLabs\efr32mg12p\Include; ..\..\..\platform\base\hal\..\..\emdrv\common\inc; ..\..\..\platform\base\hal\..\..\emdrv\config; ..\..\..\platform\base\hal\..\..\emdrv\dmadrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\gpiointerrupt\inc; ..\..\..\platform\base\hal\..\..\emdrv\rtcdrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\sleep\inc; ..\..\..\platform\base\hal\..\..\emdrv\spidrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\tempdrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\uartdrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\ustimer\inc; ..\..\..\platform\base\hal\..\..\emlib\inc; ..\..\..\platform\base\hal\..\..\middleware\glib; ..\..\..\platform\base\hal\..\..\middleware\glib\glib; ..\..\..\platform\base\hal\..\..\radio\rail_lib\plugin; ..\..\..\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\common\cortex; ..\..\..\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\rfprotocol\ieee802154\cortex; ..\..\..\platform\halconfig\inc\hal-config; ..\..\..\hardware\module\config; ..\..\..\hardware\kit\common\halconfig; ..\..\..\hardware\kit\common\bsp; hal-config; ..\..\..\platform\bootloader; ..\..\..\platform\emdrv\nvm3\inc; ..\..\..\platform\micrium_os; ..\..\..\platform\micrium_os\bsp\siliconlabs\generic\include; ..\..\..\platform\micrium_os\common\include; ..\..\..\platform\micrium_os\kernel\include; ..\..\..\platform\radio\rail_lib\chip\efr32\efr32xg1x; ..\..\..\platform\radio\rail_lib\common; ..\..\..\platform\radio\rail_lib\plugin\coexistence\common; ..\..\..\platform\radio\rail_lib\plugin\coexistence\hal\efr32; ..\..\..\platform\radio\rail_lib\plugin\coexistence\protocol\ieee802154; ..\..\..\platform\radio\rail_lib\protocol\ble; ..\..\..\platform\radio\rail_lib\protocol\ieee802154; ..\..\..\platform\radio\rail_lib\protocol\zwave; ..\..\..\protocol\zigbee\app\framework\plugin-soc\micrium-rtos\config; ..\..\..\util\third_party\mbedtls; ..\..\..\util\third_party\mbedtls\include; ..\..\..\util\third_party\mbedtls\include\mbedtls; ..\..\..\util\third_party\mbedtls\sl_crypto\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: APP_GECKO_INFO_PAGE_BTL; CORTEXM3; CORTEXM3_EFM32_MICRO; CORTEXM3_EFR32_MICRO; CORTEXM3_EFR32; EFR32_SERIES1_CONFIG2_MICRO; EFR32MG12P; EFR32MG12P433F1024GL125; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/Z3Aliyun3011/Z3Aliyun3011_endpoint_config.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; GENERATED_TOKEN_HEADER="app/builder/Z3Aliyun3011/Z3Aliyun3011_tokens.h"; PLATFORM_HEADER="platform/base/hal/micro/cortexm3/compiler/iar.h"; ZA_GENERATED_HEADER="app/builder/Z3Aliyun3011/Z3Aliyun3011.h"; HAL_CONFIG=1; EMBER_AF_USE_HWCONF; EMBER_ROUTE_TABLE_SIZE=32; EMBER_AF_API_EMBER_TYPES="stack/include/ember-types.h"; EMBER_AF_API_DEBUG_PRINT="app/framework/util/print.h"; EMBER_AF_API_AF_HEADER="app/framework/include/af.h"; EMBER_AF_API_AF_SECURITY_HEADER="app/framework/security/af-security.h"; EMBER_STACK_ZIGBEE; MBEDTLS_CONFIG_FILE="stack/config/mbedtls/config-trng.h"; USE_NVM3; NVM3_DEFAULT_NVM_SIZE=NVM3_FLASH_PAGES*FLASH_PAGE_SIZE; EMLIB_USER_CONFIG; MICRIUMOS; APPLICATION_TOKEN_HEADER="app/builder/Z3Aliyun3011/afv2-token.h"; APPLICATION_MFG_TOKEN_HEADER="app/builder/Z3Aliyun3011/afv2-mfg-token.h"; NVM3_FLASH_PAGES=18; NVM3_DEFAULT_CACHE_SIZE=512; NVM3_MAX_OBJECT_SIZE=254; NVM3_DEFAULT_REPACK_HEADROOM=0; PHY_RAIL=1
  AARM.AUserIncludes: $FILE_DIR$; $PROJ_DIR$; ..\..\..; ..\..\..\protocol\zigbee\app\framework; ..\..\..\protocol\zigbee\app\framework\..\..; ..\..\..\protocol\zigbee\app\framework\..\..\stack; ..\..\..\protocol\zigbee\app\framework\..\util; ..\..\..\protocol\zigbee\app\framework\include; ..\..\..\platform\base\hal; ..\..\..\platform\base\hal\plugin; ..\..\..\platform\base\hal\..; ..\..\..\platform\base\hal\micro\cortexm3\efm32; ..\..\..\platform\base\hal\micro\cortexm3\efm32\config; ..\..\..\platform\base\hal\micro\cortexm3\efm32\efr32; ..\..\..\platform\base\hal\..\..\CMSIS\Include; ..\..\..\platform\base\hal\..\..\Device\SiliconLabs\efr32mg12p\Include; ..\..\..\platform\base\hal\..\..\emdrv\common\inc; ..\..\..\platform\base\hal\..\..\emdrv\config; ..\..\..\platform\base\hal\..\..\emdrv\dmadrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\gpiointerrupt\inc; ..\..\..\platform\base\hal\..\..\emdrv\rtcdrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\rtcdrv\test; ..\..\..\platform\base\hal\..\..\emdrv\sleep\inc; ..\..\..\platform\base\hal\..\..\emdrv\spidrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\tempdrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\uartdrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\ustimer\inc; ..\..\..\platform\base\hal\..\..\emlib\inc; ..\..\..\platform\base\hal\..\..\middleware\glib; ..\..\..\platform\base\hal\..\..\middleware\glib\glib; ..\..\..\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\common\cortex; ..\..\..\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\rfprotocol\ieee802154\cortex; ..\..\..\platform\halconfig\inc\hal-config; ..\..\..\hardware\kit\common\halconfig; ..\..\..\hardware\kit\common\bsp; hal-config; ..\..\..\platform\bootloader; ..\..\..\platform\emdrv\nvm3\inc; ..\..\..\platform\micrium_os; ..\..\..\platform\micrium_os\bsp\siliconlabs\generic\include; ..\..\..\platform\micrium_os\common\include; ..\..\..\platform\micrium_os\kernel\include; ..\..\..\platform\radio\rail_lib\chip\efr32\efr32xg1x; ..\..\..\platform\radio\rail_lib\common; ..\..\..\platform\radio\rail_lib\plugin\coexistence\common; ..\..\..\platform\radio\rail_lib\plugin\coexistence\hal\efr32; ..\..\..\platform\radio\rail_lib\plugin\coexistence\protocol\ieee802154; ..\..\..\platform\radio\rail_lib\protocol\ble; ..\..\..\platform\radio\rail_lib\protocol\ieee802154; ..\..\..\platform\radio\rail_lib\protocol\zwave; ..\..\..\protocol\zigbee\app\framework\plugin-soc\micrium-rtos\config; ..\..\..\util\third_party\mbedtls; ..\..\..\util\third_party\mbedtls\include; ..\..\..\util\third_party\mbedtls\include\mbedtls; ..\..\..\util\third_party\mbedtls\sl_crypto\include
  OBJCOPY.OOCOutputFile: Z3Aliyun3011.s37
  prebuild: Z3Aliyun3011-prebuild.bat '$TARGET_BPATH$' '$PROJ_DIR$' '$TOOLKIT_DIR$' 'C:\SiliconLabs\SimplicityStudio\v4'
  postbuild: Z3Aliyun3011-postbuild.bat '$TARGET_BPATH$' '$PROJ_DIR$' '$TOOLKIT_DIR$' 'C:\SiliconLabs\SimplicityStudio\v4'
  ILINK.IlinkOutputFile: Z3Aliyun3011.out
  ILINK.IlinkConfigDefines: FLASH_SIZE=1048576; RAM_SIZE=262144; SIMEEPROM_SIZE=36864; LOCKBITS_IN_MAINFLASH_SIZE=0; APP_GECKO_INFO_PAGE_BTL=1; EMBER_MALLOC_HEAP_SIZE=0
  ILINK.IlinkIcfFile: ..\..\..\platform\base\hal\micro\cortexm3\efm32\iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../../app/builder/Z3Aliyun3011/: Z3Aliyun3011_callbacks.c
    ../../../platform/base/hal/micro/cortexm3/efm32/: bootloader-interface-app.c bootloader-interface.c hal-config.c hal-config-gpio.c assert-crash-handlers.c button.c cstartup-common.c diagnostic.c faults-v7m.s79 isr-stubs.s79 led.c mfg-token.c micro-common.c micro.c mpu.c sleep-efm32.c token.c ext-device.c
    ../../../platform/base/hal/plugin/serial/cortexm/efm32/: com.c
    ../../../platform/bootloader/api/: btl_interface.c btl_interface_storage.c
    ../../../platform/emdrv/uartdrv/src/: uartdrv.c
    ../../../platform/base/hal/plugin/adc/: adc-efr32.c
    ../../../protocol/zigbee/app/framework/plugin/address-table/: address-table.c address-table-cli.c
    ../../../platform/base/hal/plugin/antenna-stub/: antenna-stub.c
    ../../../platform/radio/rail_lib/plugin/coexistence/protocol/ieee802154/: coexistence-802154.c
    ../../../protocol/zigbee/app/framework/plugin/concentrator/: concentrator-support.c concentrator-support-cli.c source-route-common.c source-route.c
    ../../../protocol/zigbee/app/framework/plugin/counters/: counters-cli.c counters-ota.c counters-soc.c
    ../../../platform/base/hal/plugin/debug-jtag-stub/: debug-jtag-stub.c
    ../../../protocol/zigbee/app/framework/plugin/device-table/: device-table.c device-table-cli.c device-table-discovery.c device-table-tracking.c
    ../../../protocol/zigbee/app/framework/plugin/find-and-bind-target/: find-and-bind-target.c find-and-bind-target-cli.c
    ../../../protocol/zigbee/app/framework/plugin/form-and-join/: form-and-join-afv2.c
    ../../../protocol/zigbee/app/util/common/: form-and-join.c form-and-join-node-adapter.c
    ../../../protocol/zigbee/app/framework/plugin/identify/: identify.c identify-cli.c
    ../../../protocol/zigbee/app/framework/plugin-soc/idle-sleep/: idle-sleep.c idle-sleep-cli.c idle-sleep-soc.c
    ../../../util/third_party/mbedtls/library/: ecp.c ecdh.c bignum.c ecp_curves.c aes.c sha256.c ctr_drbg.c entropy.c ccm.c cmac.c cipher.c cipher_wrap.c threading.c
    ../../../util/third_party/mbedtls/sl_crypto/src/: aes_aes.c crypto_aes.c crypto_ble.c crypto_ecp.c crypto_management.c crypto_sha.c entropy_adc.c entropy_rail.c radioaes.c radioaes_aes.c radioaes_ble.c se_aes.c se_ccm.c se_cmac.c se_ecp.c se_management.c se_sha.c se_trng.c shax.c trng.c
    ../../../protocol/zigbee/app/framework/plugin-soc/micrium-rtos/: micrium-rtos-main.c micrium-rtos-sleep.c os_app_hooks.c
    ../../../platform/micrium_os/common/source/rtos/: rtos_err_str.c
    ../../../platform/micrium_os/common/source/kal/: kal_kernel.c
    ../../../platform/micrium_os/cpu/source/: cpu_core.c
    ../../../platform/micrium_os/kernel/source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_mon.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    ../../../platform/micrium_os/common/source/lib/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../../../platform/micrium_os/bsp/siliconlabs/generic/source/: bsp_cpu.c bsp_os.c bsp_tick_rtcc.c
    ../../../platform/micrium_os/ports/source/iar/: armv7m_cpu_c.c armv7m_cpu_a.asm armv7m_os_cpu_c.c armv7m_os_cpu_a.asm
    ../../../platform/micrium_os/ports/source/generic/: armv6m_v7m_cpu_int.c
    ../../../protocol/zigbee/app/framework/plugin/network-steering/: network-steering.c network-steering-cli.c network-steering-soc.c
    ../../../platform/emdrv/nvm3/src/: nvm3_lock.c nvm3_default.c nvm3_hal_flash.c
    ../../../protocol/zigbee/app/framework/plugin-soc/packet-handoff/: packet-handoff.c
    ../../../protocol/zigbee/app/framework/plugin/scan-dispatch/: scan-dispatch.c
    ../../../platform/base/hal/plugin/serial/: serial.c ember-printf-wrapper.c
    ../../../protocol/zigbee/app/framework/plugin/stack-diagnostics/: stack-diagnostics.c
    ../../../util/plugin/plugin-common/stack-protection-iar/: stack-protection.c
    ../../../protocol/zigbee/app/framework/plugin/update-tc-link-key/: update-tc-link-key.c update-tc-link-key-cli.c
    ./: afv2-bookkeeping.c call-command-handler.c callback-stub.c stack-handler-stub.c cli.c
    ../../../protocol/zigbee/app/framework/util/: af-event.c af-main-common.c af-main-soc.c attribute-size.c attribute-storage.c attribute-table.c client-api.c print.c print-formatter.c process-cluster-message.c process-global-message.c service-discovery-common.c service-discovery-soc.c message.c multi-network.c time-util.c util.c
    ../../../protocol/zigbee/app/framework/security/: af-node.c af-security-common.c af-trust-center.c crypto-state.c
    ../../../platform/base/hal/plugin/buzzer/: buzzer-efr32.c
    ../../../protocol/zigbee/app/framework/../util/serial/: command-interpreter2.c
    ../../../platform/base/hal/micro/generic/: crc.c endian.c mem-util.c random.c token-def.c
    ../../../protocol/zigbee/app/framework/../../stack/config/: ember-configuration.c
    ../../../protocol/zigbee/app/framework/../util/common/: library.c
    ../../../protocol/zigbee/app/framework/cli/: core-cli.c network-cli.c option-cli.c plugin-cli.c security-cli.c zcl-cli.c zdo-cli.c
    ../../../protocol/zigbee/app/framework/../util/security/: security-address-cache.c
    ../../../platform/base/hal/: ember-base-configuration.c
    ../../../protocol/zigbee/app/framework/../util/zigbee-framework/: zigbee-device-common.c zigbee-device-library.c
  group emdrv
    ../../../platform/base/hal/../../emdrv/dmadrv/src/: dmadrv.c
    ../../../platform/base/hal/../../emdrv/gpiointerrupt/src/: gpiointerrupt.c
    ../../../platform/base/hal/../../emdrv/rtcdrv/src/: rtcdriver.c
    ../../../platform/base/hal/../../emdrv/sleep/src/: sleep.c
    ../../../platform/base/hal/../../emdrv/tempdrv/src/: tempdrv.c
    ../../../platform/base/hal/../../emdrv/ustimer/src/: ustimer.c
  group emlib
    ../../../platform/base/hal/../../emlib/src/: em_adc.c em_cmu.c em_core.c em_cryotimer.c em_emu.c em_gpio.c em_i2c.c em_ldma.c em_leuart.c em_msc.c em_prs.c em_rmu.c em_rtcc.c em_se.c em_system.c em_timer.c em_usart.c em_wdog.c
    ../../../platform/base/hal/../../Device/SiliconLabs/EFR32MG12P/Source/: system_efr32mg12p.c
  group Libraries
    ../../../protocol/zigbee/build/binding-table-library-cortexm3-iar-efr32mg12p-rail/: binding-table-library.a
    ../../../protocol/zigbee/build/cbke-163k1-stub-library-cortexm3-iar-efr32mg12p-rail/: cbke-163k1-stub-library.a
    ../../../protocol/zigbee/build/cbke-283k1-stub-library-cortexm3-iar-efr32mg12p-rail/: cbke-283k1-stub-library.a
    ../../../protocol/zigbee/build/cbke-stub-library-cortexm3-iar-efr32mg12p-rail/: cbke-stub-library.a
    ../../../protocol/zigbee/build/cbke-library-dsa-sign-stub-cortexm3-iar-efr32mg12p-rail/: cbke-library-dsa-sign-stub.a
    ../../../protocol/zigbee/build/cbke-library-dsa-verify-stub-cortexm3-iar-efr32mg12p-rail/: cbke-library-dsa-verify-stub.a
    ../../../protocol/zigbee/build/cbke-library-dsa-verify-283k1-stub-cortexm3-iar-efr32mg12p-rail/: cbke-library-dsa-verify-283k1-stub.a
    ../../../protocol/zigbee/build/debug-basic-stub-library-cortexm3-iar-efr32mg12p-rail/: debug-basic-stub-library.a
    ../../../protocol/zigbee/build/debug-extended-stub-library-cortexm3-iar-efr32mg12p-rail/: debug-extended-stub-library.a
    ../../../protocol/zigbee/build/end-device-bind-stub-library-cortexm3-iar-efr32mg12p-rail/: end-device-bind-stub-library.a
    ../../../protocol/zigbee/build/gp-stub-library-cortexm3-iar-efr32mg12p-rail/: gp-stub-library.a
    ../../../protocol/zigbee/build/hal-library-cortexm3-iar-efr32mg12p-rail/: hal-library.a
    ../../../protocol/zigbee/build/install-code-library-cortexm3-iar-efr32mg12p-rail/: install-code-library.a
    ../../../protocol/zigbee/build/multi-network-stub-library-cortexm3-iar-efr32mg12p-rail/: multi-network-stub-library.a
    ../../../platform/emdrv/nvm3/lib/: libnvm3_CM4_iar.a
    ../../../protocol/zigbee/build/packet-validate-library-cortexm3-iar-efr32mg12p-rail/: packet-validate-library.a
    ../../../platform/radio/rail_lib/autogen/librail_release/: librail_efr32xg12_iar_release.a
    ../../../protocol/zigbee/build/security-library-core-cortexm3-iar-efr32mg12p-rail/: security-library-core.a
    ../../../protocol/zigbee/build/security-library-link-keys-stub-cortexm3-iar-efr32mg12p-rail/: security-library-link-keys-stub.a
    ../../../protocol/zigbee/build/sim-eeprom2-to-nvm3-upgrade-stub-library-cortexm3-iar-efr32mg12p-rail/: sim-eeprom2-to-nvm3-upgrade-stub-library.a
    ../../../protocol/zigbee/build/zigbee-pro-stack-mbedtls-trng-cortexm3-iar-efr32mg12p-rail/: zigbee-pro-stack-mbedtls-trng.a
    ../../../protocol/zigbee/build/zigbee-r22-support-stub-library-cortexm3-iar-efr32mg12p-rail/: zigbee-r22-support-stub-library.a
    ../../../protocol/zigbee/build/zll-stub-library-cortexm3-iar-efr32mg12p-rail/: zll-stub-library.a
